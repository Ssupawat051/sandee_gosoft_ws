Commit message: update_test1

File: src/urdf_sim/urdf/mobile_urdf.urdf (robot description, URDF)
Before this commit: robot sandee, 9 links, 8 joints
Joints:
- joint lidar_up_joint: origin xyz=0 0 0.038 rpy=0 0 0 -> xyz=0 0 0.2 rpy=0 0 0
